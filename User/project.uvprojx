# Keil uVision project project.uvprojx, settings and files
target Target 1 (ARM-ADS)
  device: STM32L151C8 STMicroelectronics
  pack: Keil.STM32L1xx_DFP.1.2.0
  cpu: IROM(0x08000000,0x00010000) IRAM(0x20000000,0x00002800) CPUTYPE("Cortex-M3") CLOCK(12000000) ELITTLE
  output: project +hex
  c flags: Optim=1
  c define: USE_STDPERIPH_DRIVER,STM32LXX_HD
  c include: ..\User;..\FWlib\inc;..\FWlib\src;..\CMSIS;..\BSP;..\APP
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x10000
  memory RVCT9: RAM 0x20000000 size 0x2800
  group User
    ./: main.c stm32l1xx_it.c
  group STARTUP
    ../CMSIS/: startup_stm32l1xx_mdp.s
  group FWLIB
    ../FWlib/src/: misc.c stm32l1xx_adc.c stm32l1xx_aes.c stm32l1xx_aes_util.c stm32l1xx_comp.c stm32l1xx_crc.c stm32l1xx_dac.c stm32l1xx_dbgmcu.c stm32l1xx_dma.c stm32l1xx_exti.c stm32l1xx_flash.c stm32l1xx_fsmc.c stm32l1xx_gpio.c stm32l1xx_i2c.c stm32l1xx_iwdg.c stm32l1xx_lcd.c stm32l1xx_opamp.c stm32l1xx_pwr.c stm32l1xx_rcc.c stm32l1xx_rtc.c stm32l1xx_sdio.c stm32l1xx_spi.c stm32l1xx_syscfg.c stm32l1xx_tim.c stm32l1xx_usart.c stm32l1xx_wwdg.c
  group CMSIS
    ../CMSIS/: stm32l1xx.h system_stm32l1xx.c system_stm32l1xx.h
  group BSP
    ../BSP/: bsp.c bsp_Adc.c bsp_uart_fifo.c delay.c EEPROM.c RTC.c Tim.c bsp_EEPROM_24xx.c bsp_I2C_GPIO.c
  group APP
    ../APP/: APP_EEPROM.c app_NBIOT.c app_NBRSV.c app_RS485.c app_UART1.c APP_Record.c
    ./: app_MBUS.c
